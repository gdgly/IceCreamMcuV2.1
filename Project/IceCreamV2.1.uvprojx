# Keil uVision project IceCreamV2.1.uvprojx, settings and files
target IceCreamV2_1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IceCreamV2.1
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,__TARGET_FPU_VFP
  c include: ..\User;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group User
    ../User/: main.cpp
  group User/Task
    ../User/Task/: Task.cpp
  group User/Driver
    ../User/Driver/: MicroWaveOvenUart.cpp Bluetooth.cpp Fridge.cpp PickMoto.cpp RobotArm1.cpp RobotArm2.cpp FlashMemory.cpp
  group User/Event
    ../User/Event/: Event.cpp Receiver.cpp Sender.cpp
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, CMSIS:RTOS2:Keil RTX5 5.3.0
